# IAR project roca.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\lesson\roca\CMSIS; C:\lesson\roca\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: roca.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: C:\lesson\roca\FreeRTOS; C:\lesson\roca\FreeRTOS\inc; C:\lesson\roca\Include; C:\lesson\roca\CMSIS
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: roca.hex
  group (top)
    ./: common.c init.c interface.c main.c
  group CMSIS
    CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group FreeRTOS
    FreeRTOS/: croutine.c event_groups.c heap_3.c list.c port.c portasm.s portmacro.h queue.c tasks.c timers.c
  group FreeRTOS/Inc
    FreeRTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Function
    Function/: fn_compa.c fn_contact.c fn_ecran.c
  group Include
    Include/: font_5x7.h FreeRTOSConfig.h include.h static_data.h
  group Task
    Task/: ta_compa.c ta_contact.c ta_ecran.c
